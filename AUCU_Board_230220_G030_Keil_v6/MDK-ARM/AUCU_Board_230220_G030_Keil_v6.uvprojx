# Keil uVision project AUCU_Board_230220_G030_Keil_v6.uvprojx, settings and files
target AOKU_Board_230220_G030_Keil_v6 (6180000::V6.18::ARMCLANG)
  device: STM32G030K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: AUCU_Board_230220_G030_Keil_v6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: ARM_MATH_CM0PLUS,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G030xx
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.1.0-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.1.0-Full/MotorControl/MCSDK/MCLib/G0xx/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\USER\App;..\USER\HardWare
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mcp_config.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g0xx_mc_it.c mc_tasks.c mc_parameters.c register_interface.c usart_aspep_driver.c mc_configuration_registers.c aspep.c mc_app_hooks.c stm32g0xx_it.c stm32g0xx_hal_msp.c watch_data.c User_Logic.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.1.0-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c mcp.c mcpa.c
    ../MCSDK_v6.1.0-Full/MotorControl/MCSDK/MCLib/G0xx/Src/: r3_g0xx_pwm_curr_fdbk.c
    ../Src/: flux_weakening_ctrl.c
  group HardWare
    ../USER/HardWare/: led_key.c adc_cin.c pwm_mode.c usart_handle.c lin.c
  group App
    ../USER/App/: app_error.c app_handle.c app_mode.c handle_console_pid.c
software components: CMSIS:CORE 5.6.0
